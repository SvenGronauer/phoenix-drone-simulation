Commit message: fixed: mesh path

File: phoenix_drone_simulation/envs/assets/cf21x_sys_eq.urdf (robot description, URDF)
Before this commit: robot cf21, 6 links, 5 joints
Links:
- link base_link: geometry collision cylinder length=.025 radius=.06; visual mesh filename=./meshes/cf2.dae scale=1 1 1
